<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CDC474CEU6_Tester.ewp</path>
  </project>
  <batchBuild />
</workspace>
